# Repository axellse/crackedbadusb

File readme.md:

# scriptstick

The scriptstick is a versatile scripting device in the form of a usb flash drive. It can be used for BadUsb, automation and meshtastic. The firmware writen in go, and custom scripts are written in lua. 

The scriptstick project is sponsored by [Hack club](https://hack.club).

## KiCad design hardware/crackedbadusb.kicad_pcb

Parts:
BOOT1: TS-1088-AR02016; SW-SMD_L3.9-W3.0-P4.45; LCSC Part C720477
C1, C2: 10u; C_0603_1608Metric
C3, C7: 1u; C_0603_1608Metric
C4, C5: 15p; C_0603_1608Metric
C6, C8, C9, C10, C11, C13: 100n; C_0603_1608Metric
Card2: TF-01A; TF-SMD_TF-01A; LCSC Part C91145
LED_PWR1, LED_PWR2: XL-1608UGC-04; LED0603-RD_GREEN; LCSC Part C965804
Q1: AO3400A_C347475; SOT-23-3_L2.9-W1.3-P1.90-LS2.4-BR; LCSC Part C347475
Q2: XC6220B331MR-G; SOT-25_L3.0-W1.6-P0.95-LS2.8-TL; LCSC Part C86534
R1: 5.1K; R_0603_1608Metric
R2: 10K; R_0603_1608Metric
R3, R5: 1k; R_0603_1608Metric
R6, R7: 27.4; R_0603_1608Metric
R8: 10k; R_0603_1608Metric
R9, R10: 150; R_0603_1608Metric
RESET1: TS-1088-AR02016; SW-SMD_L3.9-W3.0-P4.45; LCSC Part C720477
TP2: T5V; TestPoint_Pad_D2.0mm
TP3: PULLOUT; TestPoint_Pad_D2.5mm
TP9: SPICY_LOAD; TestPoint_Pad_D2.5mm
U1: RP2040; QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm
U2: DSHP04TSGER_C3293144; SW-SMD_8P-L6.7-W5.4-P1.27-LS8.4; LCSC Part C3293144
U3: USBLC6-2SC6; SOT-23-6
U4: W25Q128JVS; SOIC-8_5.23x5.23mm_P1.27mm
U5: ABM8-272-T3_C20625731; CRYSTAL-SMD_4P-L3.2-W2.5-BL; LCSC Part C20625731
U8: Ai-Thinker-Ra-02; Ai-Thinker-Ra-01-LoRa
USB2: U261-121N-4BS2S; USB-C-SMD_U261-121N-4BS2S; LCSC Part C2879827

Connections:
+3.3V: C2.1, C6.2, C7.2, C8.1, C9.1, C10.1, C11.1, C13.1, Card2.4 (VDD), LED_PWR1.2 (A), LED_PWR2.2 (A), Q2.5 (VOUT), R2.1, R8.2, U1.1 (IOVDD), U1.10 (IOVDD), U1.22 (IOVDD), U1.33 (IOVDD), U1.42 (IOVDD), U1.43 (ADC_AVDD), U1.44 (VREG_IN), U1.48 (USB_VDD), U1.49 (IOVDD), U4.8 (VCC), U8.3 (VDD)
GND: BOOT1.1, C1.2, C2.2, C3.1, C4.2, C5.2, C6.1, C7.1, C8.2, C9.2, C10.2, C11.2, C13.2, Card2.6 (VSS), Card2.10 (GND), Card2.11 (GND), Card2.12 (GND), Card2.13 (GND), Q1.2 (S), Q2.2 (VSS), R1.1, R9.1, RESET1.2, U1.19 (TESTEN), U1.57 (GND), U2.5, U2.6, U2.7, U2.8, U3.2 (GND), U4.4 (GND), U5.2 (GND), U5.4 (GND), U8.1 (GND), U8.2 (GND), U8.9 (GND), U8.16 (GND), USB2.25 (SHELL), USB2.26 (SHELL), USB2.A1 (GND), USB2.A12 (GND), USB2.B12 (GND)
unnamed: BOOT1.2, R5.1
unnamed: C5.1, R3.1, U5.3
unnamed: Card2.9 (CD), R10.1
unnamed: LED_PWR1.1 (K), R10.2
unnamed: LED_PWR2.1 (K), R9.2
unnamed: Q1.3 (D), TP9.1
unnamed: Q1.1 (G), U1.9 (GPIO7)
unnamed: C1.1, Q2.1 (VIN), Q2.3 (CE), TP2.1, U3.5 (VBUS), USB2.A4 (VBUS), USB2.B9 (VBUS)
unnamed: U1.4 (GPIO2), U8.6 (DIO1)
unnamed: U1.5 (GPIO3), U8.5 (DIO0)
unnamed: TP3.1, U1.8 (GPIO6)
unnamed: U1.32 (GPIO21), U8.4 (~RESET)
unnamed: U1.34 (GPIO22), U2.1
unnamed: U1.35 (GPIO23), U2.2
unnamed: U1.36 (GPIO24), U2.3
unnamed: U1.37 (GPIO25), U1.38 (GPIO26_ADC0), U1.39 (GPIO27_ADC1), U2.4
unnamed: U1.52 (QSPI_SCLK), U4.6 (CLK)
unnamed: U1.53 (QSPI_SD0), U4.5 (DI(IO0))
unnamed: U1.55 (QSPI_SD1), U4.2 (DO(IO1))
unnamed: U1.54 (QSPI_SD2), U4.3 (IO2)
unnamed: U1.51 (QSPI_SD3), U4.7 (IO3)
unnamed: R5.2, U1.56 (QSPI_SS), U4.1 (~CS)
unnamed: R2.2, RESET1.1, U1.26 (RUN)
unnamed: R7.2, U1.46 (USB_DM)
unnamed: R6.2, U1.47 (USB_DP)
unnamed: C3.2, U1.23 (DVDD), U1.45 (VREG_VOUT), U1.50 (DVDD)
unnamed: C4.1, U1.20 (XIN), U5.1
unnamed: R3.2, U1.21 (XOUT)
unnamed: R1.2, USB2.A5 (CC1)
unnamed: U3.4 (I/O2), USB2.A7 (DN1)
unnamed: U3.6 (I/O1), USB2.A6 (DP1)
SPI0_CSN: U1.7 (GPIO5), U8.15 (~NSS)
SPI0_MISO: U1.31 (GPIO20), U8.13 (MISO)
SPI0_MOSI: U1.30 (GPIO19), U8.14 (MOSI)
SPI0_SCK: U1.29 (GPIO18), U8.12 (SCK)
SPI1_CSN: Card2.2 (CDDAT3(CS)), R8.1, U1.12 (GPIO9)
SPI1_MISO: Card2.7 (DAT0(D0)), U1.11 (GPIO8)
SPI1_MOSI: Card2.3 (CMD(DI)), U1.14 (GPIO11)
SPI1_SCK: Card2.5 (CLK(SCLK)), U1.13 (GPIO10)
USB_D+: R6.1, U3.1 (I/O1)
USB_D-: R7.1, U3.3 (I/O2)

Board: 2 copper layers, 46.1 x 18.7 mm, 38 parts (5 on the bottom side), 43 nets.

## Commit log

2026-01-05 push stuff
2026-01-06 readme and poster fix
